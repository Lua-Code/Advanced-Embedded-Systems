# Keil uVision project SmartParkingGate_RTOS.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartParkingGate_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c include: .\App;.\Common;.\FSM;.\Drivers;.\Tasks
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./App/: main.c basic_io.c consoleprint.c retarget.c appConfig.h
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
  group FSM
    ./FSM/: gateStateMachine.c gateStateMachine.h
  group Drivers
    ./Drivers/: buttonDriver.c buttonDriver.h gpioDriver.c gpioDriver.h ledDriver.c ledDriver.h
  group Common
    ./Common/: events.h pins.h types.h
  group Tasks
    ./Tasks/: gateControlTask.c gateControlTask.h inputTask.c inputTask.h ledTask.c ledTask.h safetyTask.c safetyTask.h statusTask.c statusTask.h
software components: RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Coroutines 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, Device:Startup 1.0.1
